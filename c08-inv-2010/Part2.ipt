# Autodesk Inventor part: Part2
## iProperties
Created: 2006-01
Part Number: Part2
Document SubType Name: Modeling
Designer: CADCIM
Author: CADCIM
