# Autodesk Inventor part: C08TUT05
## iProperties
Created: 2009-04
Part Number: C08TUT05
Document SubType Name: Modeling
Designer: Sham
Density: 1 g/cm^3
Author: Sham
## Feature names
1. Loft1
