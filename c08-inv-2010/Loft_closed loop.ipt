# Autodesk Inventor part: loft.ipt
## iProperties
Created: 2008-06
Part Number: loft.ipt
Document SubType Name: Modeling
Designer: CADCIM
Density: 1 g/cm^3
Author: CADCIM
## Feature names
1. Loft1
