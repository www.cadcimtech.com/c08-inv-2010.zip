# Autodesk Inventor part: square-spring
## iProperties
Created: 2006-01
Part Number: square-spring
Document SubType Name: Modeling
Designer: CADCIM
Author: CADCIM
## Feature names
1. Sweep1
