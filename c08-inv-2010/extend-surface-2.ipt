# Autodesk Inventor part: extend-surface-2
## iProperties
Created: 2006-01
Part Number: extend-surface-2
Document SubType Name: Modeling
Designer: CADCIM
Author: CADCIM
